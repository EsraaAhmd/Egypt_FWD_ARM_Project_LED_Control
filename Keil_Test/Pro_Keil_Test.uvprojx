# Keil uVision project Pro_Keil_Test.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro_Keil_Test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Egypt_FWD_ARM_Project_LED_Control\APP\Inc;..\Egypt_FWD_ARM_Project_LED_Control\LIB\Common\Inc;..\Egypt_FWD_ARM_Project_LED_Control\LIB\Configuration\Inc;..\Egypt_FWD_ARM_Project_LED_Control\MCAL\Inc;..\Egypt_FWD_ARM_Project_LED_Control\Services\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../Egypt_FWD_ARM_Project_LED_Control/APP/Src/: main.c
  group LIB
    ../Egypt_FWD_ARM_Project_LED_Control/LIB/Configuration/Src/: port_cfg.c IntCtrl_cfg.c
  group MCAL
    ../Egypt_FWD_ARM_Project_LED_Control/MCAL/Src/: gpio.c intctrl.c port_driver.c systick.c
  group Services
    ../Egypt_FWD_ARM_Project_LED_Control/Services/Src/: simulated_PWM.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
